# Keil uVision project Test.uvprojx, settings and files
target Test (6220000::V6.22::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\peripheralDriver\mpu6050;..\peripheralDriver\Motor;..\peripheralDriver\E49;../PID;..\peripheralDriver\SPL06;..\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c dma.c i2c.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group peripheralDriver
    ../peripheralDriver/E49/: E49.h E49.c
    ../peripheralDriver/Motor/: motor.h motor.c
    ../peripheralDriver/mpu6050/: dmpKey.h dmpmap.h inv_mpu.h inv_mpu.c inv_mpu_dmp_motion_driver.h inv_mpu_dmp_motion_driver.c
    ../peripheralDriver/SPL06/: SPL06001.h SPL06001.c
  group HAL
    ../HAL/: config.h config.c filter.h filter.c interruptProcess.h interruptProcess.c systeminit.h systeminit.c uartProcess.h uartProcess.c task.h task.c
  group PID
    ../PID/: pid.h pid.c
software components: CMSIS:CORE 6.1.0
